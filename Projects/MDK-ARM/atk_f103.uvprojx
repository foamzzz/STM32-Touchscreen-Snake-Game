# Keil uVision project atk_f103.uvprojx, settings and files
target GTIM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c array_chinese.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/TIMER/: gtim.c
    ../../Drivers/BSP/LCD/: lcd.c
  group Readme
    ../../: readme.txt
  group TOUCH
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
  group KEY
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/EXTI/: exti.c
